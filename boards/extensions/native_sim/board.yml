## boards/extensions/native_sim/board.yml
```yaml
# SPDX-FileCopyrightText: 2026 Alicipy <dev@stefankraus.org>
#
# SPDX-License-Identifier: Apache-2.0

board:
  extend: native_sim
```
